# IAR project Actual code.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: \Program Files\Best\BRAIN\include\
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: brainuser.r43
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group (top)
    ./: main.c wizardgen.h wizardpost.h wizardvars.h
